# Keil uVision project GPIO_Toggle.uvprojx, settings and files
target APM32F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F103VB Geehy
  pack: Geehy.APM32F1xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_Toggle +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F10X_HD,APM32F103_MINI
  c include: ..\..\Include;..\..\..\..\..\Board;..\..\..\..\..\Library\APM32F10x_StdPeriphDriver\inc;..\..\..\..\..\Library\CMSIS\Include;..\..\..\..\..\Library\Device\Geehy\APM32F10x\Include;..\..\..\..\..\Library\DHT11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../../../../../Library/Device/Geehy/APM32F10x/Source/: system_apm32f10x.c
    ../../../../../Library/Device/Geehy/APM32F10x/Source/arm/: startup_apm32f10x_hd.s startup_apm32f10x_md.s
  group StdPeriphDriver
    ../../../../../Library/APM32F10x_StdPeriphDriver/src/: apm32f10x_gpio.c apm32f10x_rcm.c apm32f10x_usart.c
  group Application
    ../../Source/: main.c apm32f10x_int.c
  group DHT11
    ../../../../../Library/DHT11/: dht11.c
